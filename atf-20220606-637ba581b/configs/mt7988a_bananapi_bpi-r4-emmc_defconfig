## atf-20220606-637ba581b/configs/mt7988a_bananapi_bpi-r4-emmc_defconfig
```kconfig
CONFIG_PLAT_MT7988=y
CONFIG_TARGET_FIP_NO_SEC_BOOT=y
CONFIG_FLASH_DEVICE_EMMC=y
CONFIG_DRAM_DDR4=y
```
